# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: DiskImg.c memory.c memory.h msc.h mscuser.c mscuser.h Startup.s type.h usb.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h project.lib
